require recipes-kernel/linux-libc-headers/linux-libc-headers.inc

KORG_ARCHIVE_COMPRESSION = "xz"

SRC_URI[md5sum] = "688e92ff6f0132586fce97b10d8c2c4f"
SRC_URI[sha256sum] = "18987c2e9a8f5e2583b1ac5c2bed52777b8730ab29612a5b70c94fa17c659803"

