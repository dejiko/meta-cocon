require recipes-kernel/linux-libc-headers/linux-libc-headers.inc

KORG_ARCHIVE_COMPRESSION = "xz"

SRC_URI[md5sum] = "1c0c682d7776ffad05bf799a1e88320d"
SRC_URI[sha256sum] = "f8e2403614e5a8c3f511ecebeec27c22bc7187dfb2e5e19bea08f9d2082e764c"

