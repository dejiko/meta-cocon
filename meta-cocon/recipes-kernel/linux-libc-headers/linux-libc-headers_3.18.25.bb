KORG_ARCHIVE_COMPRESSION = "xz"

require recipes-kernel/linux-libc-headers/linux-libc-headers.inc

SRC_URI[md5sum] = "929e74f2e29e1b41d69e45c04d712c9e"
SRC_URI[sha256sum] = "c649874e2856101df7cefe5fdad313ebb2282a939fc1e95cf02222327745ff92"
