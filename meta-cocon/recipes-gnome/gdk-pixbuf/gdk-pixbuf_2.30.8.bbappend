# look for files in the layer first
FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

GDK_PIXBUF_LOADERS = "png jpeg x11"
