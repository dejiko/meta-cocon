FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

PACKAGECONFIG += "icu"

