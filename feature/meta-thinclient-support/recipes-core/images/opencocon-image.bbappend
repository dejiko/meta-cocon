DESCRIPTION = "opencocon Thinclient Desktop" 


IMAGE_INSTALL_append = " \
    opencocon-init \
"
