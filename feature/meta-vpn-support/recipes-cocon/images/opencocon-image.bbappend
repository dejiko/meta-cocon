DESCRIPTION = "opencocon VPN Support"

IMAGE_INSTALL_append = " \
    softether \
    "

