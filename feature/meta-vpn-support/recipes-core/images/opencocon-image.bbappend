IMAGE_INSTALL_append = " \
    packagegroup-opencocon-vpn \
    "

