FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

# Default is to use stable kernel version
# If you want to use latest git version set to "1"
DEFAULT_PREFERENCE = "1" 
