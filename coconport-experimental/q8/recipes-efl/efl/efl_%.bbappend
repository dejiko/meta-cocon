FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

#SRC_URI += "file://evas-gl.patch"

PACKAGECONFIG += "opengl-none"
