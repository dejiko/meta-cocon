EXTRAPATHS_prepend := "${THISDIR}/${PN}:"

ETHEME = "e-wm-theme-illume-efenniht"
