FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

IMAGE_FSTYPES += "cpio.gz cramfs.gz"

#IMAGE_INSTALL += " \
#"
