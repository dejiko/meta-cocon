# Released under the MIT license (see COPYING.MIT for the terms)

DESCRIPTION = "Packagegroup for opencocon thinclient on cocon486 machine (Debug)"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://${COREBASE}/LICENSE;md5=4d92cd373abda3937c2bc47fbc49d690"

inherit packagegroup

COMPATIBLE_MACHINE = "cocon486"

#RDEPENDS_${PN} = " \
#xf86-video-chips-dbg \
#xf86-video-sis-dbg \
#gdb \
#"


