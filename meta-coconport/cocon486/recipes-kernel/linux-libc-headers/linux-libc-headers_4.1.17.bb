KORG_ARCHIVE_COMPRESSION = "xz"

require recipes-kernel/linux-libc-headers/linux-libc-headers.inc

SRC_URI[md5sum] = "4b0bd6b3775170ce0f76ef219ac279d8"
SRC_URI[sha256sum] = "4b19988e252d4a954d86f9a5aa2d32e11e6131ad182f25b3a447d4b753909120"

