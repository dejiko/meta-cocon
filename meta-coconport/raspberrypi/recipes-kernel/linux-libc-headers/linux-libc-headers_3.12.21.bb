require recipes-kernel/linux-libc-headers/linux-libc-headers.inc

KORG_ARCHIVE_COMPRESSION = "xz"

SRC_URI[md5sum] = "abc7976416d7e37867c3491db4c304be"
SRC_URI[sha256sum] = "e7c1ace335e3946f3575b98def5c0f84b9b002e16281742012bfbf85487e24df"

