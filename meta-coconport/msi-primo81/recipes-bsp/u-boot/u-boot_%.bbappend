FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"


# add sun6i
COMPATIBLE_MACHINE = "(sun4i|sun5i|sun6i|sun7i)"
DEFAULT_PREFERENCE_sun6i="1"

