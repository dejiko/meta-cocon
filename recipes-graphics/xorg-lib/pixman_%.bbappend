FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

CFLAGS += " -DPIXMAN_NO_TLS "
CPPFLAGS += " -DPIXMAN_NO_TLS "
