require recipes-graphics/xorg-driver/xorg-driver-video.inc

DESCRIPTION = "X.Org X server -- i740 display driver"

LIC_FILES_CHKSUM = "file://COPYING;md5=c85da4d100605ac6d8d47d47eb2bf191"

SRC_URI[md5sum] = "2dc0a0b4665353f97d8a1c874659cdec"
SRC_URI[sha256sum] = "1ce02dd0a11fbf6b43b8bca6663c67149d7d740c8985ae18bd956eddeaffe324"

