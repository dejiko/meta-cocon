# look for files in the layer first
FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRCREV = "c6cb1b199598c572484fb4e30e1026be9d4ccc31"
