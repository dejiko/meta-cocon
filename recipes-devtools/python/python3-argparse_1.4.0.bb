DESCRIPTION = "Python command-line parsing library"
HOMEPAGE = "https://github.com/ThomasWaldmann/argparse/"
SECTION = "devel/python"
LICENSE = "Python-2.0"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=09d08bb5b7047e2688ea3faad6408aa8"

SRC_URI[md5sum] = "08062d2ceb6596fcbc5a7e725b53746f"
SRC_URI[sha256sum] = "62b089a55be1d8949cd2bc7e0df0bddb9e028faefc8c32038cc84862aefdd6e4"

inherit pypi setuptools3
