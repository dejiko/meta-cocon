FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

#SRC_URI_append_libc-musl += "file://dhcp-4.3.2-fix-compilation-for-musl.patch"
