FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

#SRC_URI_append_libc-musl += "file://0001-fbset-including-asm-types.h-is-needed-on-all-linux-s.patch"

